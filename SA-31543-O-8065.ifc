Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-09-05T13:39:38
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: SA-31543-O-8065
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: SA-31543-O-8065; Light output ratio: 1; Luminous flux: 2342 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 2342 lm; LightEmitterNominalPower: 27 W; Spectrum: 380: 0, 385: 0, 390: 178558751399, 395: 12734896263, 400: 123089325907, 405: 261516805548, 410: 1464231170235, 415: 430294922831, 420: 10681548125474, 425: 2306222259826, 430: 43895722382671, 435: 73383826938745, 440: 11409864270161, 445: 173920328308268, 450: 223082632201111, 455: 204137126118961, 460: 141610150565822, 465: 98522029276188, 470: 75787656306087, 475: 61465325634555, 480: 50628022028321, 485: 43804133405504, 490: 41096014710697, 495: 41296806042095, 500: 46022365515858, 505: 53994223202378, 510: 63657148322925, 515: 7300111865812, 520: 82232023656623, 525: 90072795556808, 530: 94477943674646, 535: 100183702501118, 540: 102974114471463, 545: 104831823189484, 550: 105588352475001, 555: 105397064512856, 560: 10485419683802, 565: 102067863885198, 570: 10154631751924, 575: 99088252852285, 580: 96092263252841, 585: 93050141038832, 590: 89223402958731, 595: 8687735854356, 600: 83784825613313, 605: 78513561130398, 610: 74892245849561, 615: 6886326909333, 620: 65016604523355, 625: 59939194321171, 630: 54191424737451, 635: 50179897423429, 640: 46206524127835, 645: 43240631310898, 650: 38425089993302, 655: 35479145967417, 660: 3201874778213, 665: 28664249770387, 670: 26902346905883, 675: 23043512446775, 680: 20868790804797, 685: 18608189610671, 690: 16748432355076, 695: 1497941522252, 700: 13578257224665, 705: 11850454357176, 710: 10448656566906, 715: 9190909619001, 720: 8034158211069, 725: 7362155901649, 730: 6620249398244, 735: 4918410197886, 740: 4811132280479, 745: 4143048761997, 750: 3381913597652, 755: 304415347395, 760: 2322430178544, 765: 204837839481, 770: 166024621022, 775: 1951427526769, 780: 876575691094; ColorTemperature: 6500 K; ColorRenderingIndex: 80

# IfcFlowTerminal: SANDY 8 Surface facade luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour TW(2700K - 6500K) - Die-cast aluminium housing and frame - Pre-treated before powder coating ensuring high corrosion resistance - Two cable entries for through wiring - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Opal UV-stabilised polycarbonate diffuser - Optional surface mounting box for easy wiring or conduit connection when wiring from behind is not possible; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: SANDY, Surface mounter luminaires; Housing color: Not specified
General Information - Article number: SA-31543-O-8065; Article name: SANDY 8 Surface facade luminaires; Weight: 4.2 kg; Case height: 13.5 cm; Case diameter: 35.5 cm; Uld creation date: 09.05.2022 00:00:00
Mounting Information - Mounting height: 200 cm; Recessed depth: 0 cm
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 27.881 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 27.881 W; LightFixtureMountingType: WallMounted; LightFixturePlacingType: Wall; ManufacturersSpecificInformation: LIGMAN
